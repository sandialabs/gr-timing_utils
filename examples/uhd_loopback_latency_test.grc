<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_loopback_latency_test</value></param>
<param><key>author</key><value>J. Gilbert</value></param>
<param><key>description</key><value>evaluates loopback latency</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>UHD Loopback Latency Test</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>args</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"recv_frame_size=256, num_recv_frames=256, send_frame_size=256, num_send_frames=256"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>args</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>args</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"recv_frame_size=64, num_recv_frames=1024, send_frame_size=64, num_send_frames=1024"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>el</value></param>
<param><key>value</key><value>len(es)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>es</value></param>
<param><key>comment</key><value>End Symbols</value></param>
<param><key>value</key><value>numpy.array([1.000000 + -0.000000j, 0.999699 + 0.024541j, 0.998795 + 0.049068j, 0.997290 + 0.073565j, 0.995185 + 0.098017j, 0.992480 + 0.122411j, 0.989177 + 0.146730j, 0.985278 + 0.170962j, 0.980785 + 0.195090j, 0.975702 + 0.219101j, 0.970031 + 0.242980j, 0.963776 + 0.266713j, 0.956940 + 0.290285j, 0.949528 + 0.313682j, 0.941544 + 0.336890j, 0.932993 + 0.359895j, 0.923880 + 0.382683j, 0.914210 + 0.405241j, 0.903989 + 0.427555j, 0.893224 + 0.449611j, 0.881921 + 0.471397j, 0.870087 + 0.492898j, 0.857729 + 0.514103j, 0.844854 + 0.534998j, 0.831470 + 0.555570j, 0.817585 + 0.575808j, 0.803208 + 0.595699j, 0.788346 + 0.615232j, 0.773010 + 0.634393j, 0.757209 + 0.653173j, 0.740951 + 0.671559j, 0.724247 + 0.689541j, 0.707107 + 0.707107j, 0.689541 + 0.724247j, 0.671559 + 0.740951j, 0.653173 + 0.757209j, 0.634393 + 0.773010j, 0.615232 + 0.788346j, 0.595699 + 0.803208j, 0.575808 + 0.817585j, 0.555570 + 0.831470j, 0.534998 + 0.844854j, 0.514103 + 0.857729j, 0.492898 + 0.870087j, 0.471397 + 0.881921j, 0.449611 + 0.893224j, 0.427555 + 0.903989j, 0.405241 + 0.914210j, 0.382683 + 0.923880j, 0.359895 + 0.932993j, 0.336890 + 0.941544j, 0.313682 + 0.949528j, 0.290285 + 0.956940j, 0.266713 + 0.963776j, 0.242980 + 0.970031j, 0.219101 + 0.975702j, 0.195090 + 0.980785j, 0.170962 + 0.985278j, 0.146730 + 0.989177j, 0.122411 + 0.992480j, 0.098017 + 0.995185j, 0.073565 + 0.997290j, 0.049068 + 0.998795j, 0.024541 + 0.999699j, 0.000000 + 1.000000j, -0.024541 + 0.999699j, -0.049068 + 0.998795j, -0.073565 + 0.997290j, -0.098017 + 0.995185j, -0.122411 + 0.992480j, -0.146730 + 0.989177j, -0.170962 + 0.985278j, -0.195090 + 0.980785j, -0.219101 + 0.975702j, -0.242980 + 0.970031j, -0.266713 + 0.963776j, -0.290285 + 0.956940j, -0.313682 + 0.949528j, -0.336890 + 0.941544j, -0.359895 + 0.932993j, -0.382683 + 0.923880j, -0.405241 + 0.914210j, -0.427555 + 0.903989j, -0.449611 + 0.893224j, -0.471397 + 0.881921j, -0.492898 + 0.870087j, -0.514103 + 0.857729j, -0.534998 + 0.844854j, -0.555570 + 0.831470j, -0.575808 + 0.817585j, -0.595699 + 0.803208j, -0.615232 + 0.788346j, -0.634393 + 0.773010j, -0.653173 + 0.757209j, -0.671559 + 0.740951j, -0.689541 + 0.724247j, -0.707107 + 0.707107j, -0.724247 + 0.689541j, -0.740951 + 0.671559j, -0.757209 + 0.653173j, -0.773010 + 0.634393j, -0.788346 + 0.615232j, -0.803208 + 0.595699j, -0.817585 + 0.575808j, -0.831470 + 0.555570j, -0.844854 + 0.534998j, -0.857729 + 0.514103j, -0.870087 + 0.492898j, -0.881921 + 0.471397j, -0.893224 + 0.449611j, -0.903989 + 0.427555j, -0.914210 + 0.405241j, -0.923880 + 0.382683j, -0.932993 + 0.359895j, -0.941544 + 0.336890j, -0.949528 + 0.313682j, -0.956940 + 0.290285j, -0.963776 + 0.266713j, -0.970031 + 0.242980j, -0.975702 + 0.219101j, -0.980785 + 0.195090j, -0.985278 + 0.170962j, -0.989177 + 0.146730j, -0.992480 + 0.122411j, -0.995185 + 0.098017j, -0.997290 + 0.073565j, -0.998795 + 0.049068j, -0.999699 + 0.024541j, -1.000000 + 0.000000j, -0.999699 + -0.024541j, -0.998795 + -0.049068j, -0.997290 + -0.073565j, -0.995185 + -0.098017j, -0.992480 + -0.122411j, -0.989177 + -0.146730j, -0.985278 + -0.170962j, -0.980785 + -0.195090j, -0.975702 + -0.219101j, -0.970031 + -0.242980j, -0.963776 + -0.266713j, -0.956940 + -0.290285j, -0.949528 + -0.313682j, -0.941544 + -0.336890j, -0.932993 + -0.359895j, -0.923880 + -0.382683j, -0.914210 + -0.405241j, -0.903989 + -0.427555j, -0.893224 + -0.449611j, -0.881921 + -0.471397j, -0.870087 + -0.492898j, -0.857729 + -0.514103j, -0.844854 + -0.534998j, -0.831470 + -0.555570j, -0.817585 + -0.575808j, -0.803208 + -0.595699j, -0.788346 + -0.615232j, -0.773010 + -0.634393j, -0.757209 + -0.653173j, -0.740951 + -0.671559j, -0.724247 + -0.689541j, -0.707107 + -0.707107j, -0.689541 + -0.724247j, -0.671559 + -0.740951j, -0.653173 + -0.757209j, -0.634393 + -0.773010j, -0.615232 + -0.788346j, -0.595699 + -0.803208j, -0.575808 + -0.817585j, -0.555570 + -0.831470j, -0.534998 + -0.844854j, -0.514103 + -0.857729j, -0.492898 + -0.870087j, -0.471397 + -0.881921j, -0.449611 + -0.893224j, -0.427555 + -0.903989j, -0.405241 + -0.914210j, -0.382683 + -0.923880j, -0.359895 + -0.932993j, -0.336890 + -0.941544j, -0.313682 + -0.949528j, -0.290285 + -0.956940j, -0.266713 + -0.963776j, -0.242980 + -0.970031j, -0.219101 + -0.975702j, -0.195090 + -0.980785j, -0.170962 + -0.985278j, -0.146730 + -0.989177j, -0.122411 + -0.992480j, -0.098017 + -0.995185j, -0.073565 + -0.997290j, -0.049068 + -0.998795j, -0.024541 + -0.999699j, 0.000000 + -1.000000j, 0.024534 + -0.999398j, 0.049009 + -0.997592j, 0.073365 + -0.994588j, 0.097545 + -0.990393j, 0.121490 + -0.985016j, 0.145142 + -0.978470j, 0.168445 + -0.970772j, 0.191342 + -0.961940j, 0.213778 + -0.951995j, 0.235698 + -0.940961j, 0.257051 + -0.928864j, 0.277785 + -0.915735j, 0.297850 + -0.901604j, 0.317197 + -0.886505j, 0.335779 + -0.870476j, 0.353553 + -0.853553j, 0.370476 + -0.835779j, 0.386505 + -0.817197j, 0.401604 + -0.797850j, 0.415735 + -0.777785j, 0.428864 + -0.757051j, 0.440961 + -0.735698j, 0.451995 + -0.713778j, 0.461940 + -0.691342j, 0.470772 + -0.668445j, 0.478470 + -0.645142j, 0.485016 + -0.621490j, 0.490393 + -0.597545j, 0.494588 + -0.573365j, 0.497592 + -0.549009j, 0.499398 + -0.524534j, 0.500000 + -0.500000j, 0.499398 + -0.475466j, 0.497592 + -0.450991j, 0.494588 + -0.426635j, 0.490393 + -0.402455j, 0.485016 + -0.378510j, 0.478470 + -0.354858j, 0.470772 + -0.331555j, 0.461940 + -0.308658j, 0.451995 + -0.286222j, 0.440961 + -0.264302j, 0.428864 + -0.242949j, 0.415735 + -0.222215j, 0.401604 + -0.202150j, 0.386505 + -0.182803j, 0.370476 + -0.164221j, 0.353553 + -0.146447j, 0.335779 + -0.129524j, 0.317197 + -0.113495j, 0.297850 + -0.098396j, 0.277785 + -0.084265j, 0.257051 + -0.071136j, 0.235698 + -0.059039j, 0.213778 + -0.048005j, 0.191342 + -0.038060j, 0.168445 + -0.029228j, 0.145142 + -0.021530j, 0.121490 + -0.014984j, 0.097545 + -0.009607j, 0.073365 + -0.005412j, 0.049009 + -0.002408j, 0.024534 + -0.000602j], dtype=numpy.complex64)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>900e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>s</value></param>
<param><key>comment</key><value>Symbols</value></param>
<param><key>value</key><value>numpy.array([1.000000 + -0.000000j, 0.999699 + 0.024541j, 0.998795 + 0.049068j, 0.997290 + 0.073565j, 0.995185 + 0.098017j, 0.992480 + 0.122411j, 0.989177 + 0.146730j, 0.985278 + 0.170962j, 0.980785 + 0.195090j, 0.975702 + 0.219101j, 0.970031 + 0.242980j, 0.963776 + 0.266713j, 0.956940 + 0.290285j, 0.949528 + 0.313682j, 0.941544 + 0.336890j, 0.932993 + 0.359895j, 0.923880 + 0.382683j, 0.914210 + 0.405241j, 0.903989 + 0.427555j, 0.893224 + 0.449611j, 0.881921 + 0.471397j, 0.870087 + 0.492898j, 0.857729 + 0.514103j, 0.844854 + 0.534998j, 0.831470 + 0.555570j, 0.817585 + 0.575808j, 0.803208 + 0.595699j, 0.788346 + 0.615232j, 0.773010 + 0.634393j, 0.757209 + 0.653173j, 0.740951 + 0.671559j, 0.724247 + 0.689541j, 0.707107 + 0.707107j, 0.689541 + 0.724247j, 0.671559 + 0.740951j, 0.653173 + 0.757209j, 0.634393 + 0.773010j, 0.615232 + 0.788346j, 0.595699 + 0.803208j, 0.575808 + 0.817585j, 0.555570 + 0.831470j, 0.534998 + 0.844854j, 0.514103 + 0.857729j, 0.492898 + 0.870087j, 0.471397 + 0.881921j, 0.449611 + 0.893224j, 0.427555 + 0.903989j, 0.405241 + 0.914210j, 0.382683 + 0.923880j, 0.359895 + 0.932993j, 0.336890 + 0.941544j, 0.313682 + 0.949528j, 0.290285 + 0.956940j, 0.266713 + 0.963776j, 0.242980 + 0.970031j, 0.219101 + 0.975702j, 0.195090 + 0.980785j, 0.170962 + 0.985278j, 0.146730 + 0.989177j, 0.122411 + 0.992480j, 0.098017 + 0.995185j, 0.073565 + 0.997290j, 0.049068 + 0.998795j, 0.024541 + 0.999699j, 0.000000 + 1.000000j, -0.024541 + 0.999699j, -0.049068 + 0.998795j, -0.073565 + 0.997290j, -0.098017 + 0.995185j, -0.122411 + 0.992480j, -0.146730 + 0.989177j, -0.170962 + 0.985278j, -0.195090 + 0.980785j, -0.219101 + 0.975702j, -0.242980 + 0.970031j, -0.266713 + 0.963776j, -0.290285 + 0.956940j, -0.313682 + 0.949528j, -0.336890 + 0.941544j, -0.359895 + 0.932993j, -0.382683 + 0.923880j, -0.405241 + 0.914210j, -0.427555 + 0.903989j, -0.449611 + 0.893224j, -0.471397 + 0.881921j, -0.492898 + 0.870087j, -0.514103 + 0.857729j, -0.534998 + 0.844854j, -0.555570 + 0.831470j, -0.575808 + 0.817585j, -0.595699 + 0.803208j, -0.615232 + 0.788346j, -0.634393 + 0.773010j, -0.653173 + 0.757209j, -0.671559 + 0.740951j, -0.689541 + 0.724247j, -0.707107 + 0.707107j, -0.724247 + 0.689541j, -0.740951 + 0.671559j, -0.757209 + 0.653173j, -0.773010 + 0.634393j, -0.788346 + 0.615232j, -0.803208 + 0.595699j, -0.817585 + 0.575808j, -0.831470 + 0.555570j, -0.844854 + 0.534998j, -0.857729 + 0.514103j, -0.870087 + 0.492898j, -0.881921 + 0.471397j, -0.893224 + 0.449611j, -0.903989 + 0.427555j, -0.914210 + 0.405241j, -0.923880 + 0.382683j, -0.932993 + 0.359895j, -0.941544 + 0.336890j, -0.949528 + 0.313682j, -0.956940 + 0.290285j, -0.963776 + 0.266713j, -0.970031 + 0.242980j, -0.975702 + 0.219101j, -0.980785 + 0.195090j, -0.985278 + 0.170962j, -0.989177 + 0.146730j, -0.992480 + 0.122411j, -0.995185 + 0.098017j, -0.997290 + 0.073565j, -0.998795 + 0.049068j, -0.999699 + 0.024541j, -1.000000 + 0.000000j, -0.999699 + -0.024541j, -0.998795 + -0.049068j, -0.997290 + -0.073565j, -0.995185 + -0.098017j, -0.992480 + -0.122411j, -0.989177 + -0.146730j, -0.985278 + -0.170962j, -0.980785 + -0.195090j, -0.975702 + -0.219101j, -0.970031 + -0.242980j, -0.963776 + -0.266713j, -0.956940 + -0.290285j, -0.949528 + -0.313682j, -0.941544 + -0.336890j, -0.932993 + -0.359895j, -0.923880 + -0.382683j, -0.914210 + -0.405241j, -0.903989 + -0.427555j, -0.893224 + -0.449611j, -0.881921 + -0.471397j, -0.870087 + -0.492898j, -0.857729 + -0.514103j, -0.844854 + -0.534998j, -0.831470 + -0.555570j, -0.817585 + -0.575808j, -0.803208 + -0.595699j, -0.788346 + -0.615232j, -0.773010 + -0.634393j, -0.757209 + -0.653173j, -0.740951 + -0.671559j, -0.724247 + -0.689541j, -0.707107 + -0.707107j, -0.689541 + -0.724247j, -0.671559 + -0.740951j, -0.653173 + -0.757209j, -0.634393 + -0.773010j, -0.615232 + -0.788346j, -0.595699 + -0.803208j, -0.575808 + -0.817585j, -0.555570 + -0.831470j, -0.534998 + -0.844854j, -0.514103 + -0.857729j, -0.492898 + -0.870087j, -0.471397 + -0.881921j, -0.449611 + -0.893224j, -0.427555 + -0.903989j, -0.405241 + -0.914210j, -0.382683 + -0.923880j, -0.359895 + -0.932993j, -0.336890 + -0.941544j, -0.313682 + -0.949528j, -0.290285 + -0.956940j, -0.266713 + -0.963776j, -0.242980 + -0.970031j, -0.219101 + -0.975702j, -0.195090 + -0.980785j, -0.170962 + -0.985278j, -0.146730 + -0.989177j, -0.122411 + -0.992480j, -0.098017 + -0.995185j, -0.073565 + -0.997290j, -0.049068 + -0.998795j, -0.024541 + -0.999699j, -0.000000 + -1.000000j, 0.024541 + -0.999699j, 0.049068 + -0.998795j, 0.073565 + -0.997290j, 0.098017 + -0.995185j, 0.122411 + -0.992480j, 0.146730 + -0.989177j, 0.170962 + -0.985278j, 0.195090 + -0.980785j, 0.219101 + -0.975702j, 0.242980 + -0.970031j, 0.266713 + -0.963776j, 0.290285 + -0.956940j, 0.313682 + -0.949528j, 0.336890 + -0.941544j, 0.359895 + -0.932993j, 0.382683 + -0.923880j, 0.405241 + -0.914210j, 0.427555 + -0.903989j, 0.449611 + -0.893224j, 0.471397 + -0.881921j, 0.492898 + -0.870087j, 0.514103 + -0.857729j, 0.534998 + -0.844854j, 0.555570 + -0.831470j, 0.575808 + -0.817585j, 0.595699 + -0.803208j, 0.615232 + -0.788346j, 0.634393 + -0.773010j, 0.653173 + -0.757209j, 0.671559 + -0.740951j, 0.689541 + -0.724247j, 0.707107 + -0.707107j, 0.724247 + -0.689541j, 0.740951 + -0.671559j, 0.757209 + -0.653173j, 0.773010 + -0.634393j, 0.788346 + -0.615232j, 0.803208 + -0.595699j, 0.817585 + -0.575808j, 0.831470 + -0.555570j, 0.844854 + -0.534998j, 0.857729 + -0.514103j, 0.870087 + -0.492898j, 0.881921 + -0.471397j, 0.893224 + -0.449611j, 0.903989 + -0.427555j, 0.914210 + -0.405241j, 0.923880 + -0.382683j, 0.932993 + -0.359895j, 0.941544 + -0.336890j, 0.949528 + -0.313682j, 0.956940 + -0.290285j, 0.963776 + -0.266713j, 0.970031 + -0.242980j, 0.975702 + -0.219101j, 0.980785 + -0.195090j, 0.985278 + -0.170962j, 0.989177 + -0.146730j, 0.992480 + -0.122411j, 0.995185 + -0.098017j, 0.997290 + -0.073565j, 0.998795 + -0.049068j, 0.999699 + -0.024541j], dtype=numpy.complex64)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sl</value></param>
<param><key>value</key><value>len(s)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ss</value></param>
<param><key>comment</key><value>Start Symbols</value></param>
<param><key>value</key><value>numpy.array([0.049068 + 0.000000j, 0.097988 + 0.002405j, 0.146554 + 0.007200j, 0.194562 + 0.014352j, 0.241810 + 0.023816j, 0.288102 + 0.035534j, 0.333244 + 0.049432j, 0.377049 + 0.065424j, 0.419340 + 0.083412j, 0.459943 + 0.103284j, 0.498696 + 0.124917j, 0.535445 + 0.148178j, 0.570049 + 0.172922j, 0.602374 + 0.198998j, 0.632302 + 0.226241j, 0.659726 + 0.254484j, 0.684550 + 0.283550j, 0.706694 + 0.313256j, 0.726091 + 0.343415j, 0.742689 + 0.373838j, 0.756449 + 0.404330j, 0.767348 + 0.434697j, 0.775377 + 0.464743j, 0.780543 + 0.494273j, 0.782865 + 0.523094j, 0.782380 + 0.551014j, 0.779136 + 0.577847j, 0.773199 + 0.603410j, 0.764644 + 0.627527j, 0.753563 + 0.650028j, 0.740059 + 0.670750j, 0.724247 + 0.689541j, 0.707107 + 0.707107j, 0.689541 + 0.724247j, 0.671559 + 0.740951j, 0.653173 + 0.757209j, 0.634393 + 0.773010j, 0.615232 + 0.788346j, 0.595699 + 0.803208j, 0.575808 + 0.817585j, 0.555570 + 0.831470j, 0.534998 + 0.844854j, 0.514103 + 0.857729j, 0.492898 + 0.870087j, 0.471397 + 0.881921j, 0.449611 + 0.893224j, 0.427555 + 0.903989j, 0.405241 + 0.914210j, 0.382683 + 0.923880j, 0.359895 + 0.932993j, 0.336890 + 0.941544j, 0.313682 + 0.949528j, 0.290285 + 0.956940j, 0.266713 + 0.963776j, 0.242980 + 0.970031j, 0.219101 + 0.975702j, 0.195090 + 0.980785j, 0.170962 + 0.985278j, 0.146730 + 0.989177j, 0.122411 + 0.992480j, 0.098017 + 0.995185j, 0.073565 + 0.997290j, 0.049068 + 0.998795j, 0.024541 + 0.999699j, 0.000000 + 1.000000j, -0.024541 + 0.999699j, -0.049068 + 0.998795j, -0.073565 + 0.997290j, -0.098017 + 0.995185j, -0.122411 + 0.992480j, -0.146730 + 0.989177j, -0.170962 + 0.985278j, -0.195090 + 0.980785j, -0.219101 + 0.975702j, -0.242980 + 0.970031j, -0.266713 + 0.963776j, -0.290285 + 0.956940j, -0.313682 + 0.949528j, -0.336890 + 0.941544j, -0.359895 + 0.932993j, -0.382683 + 0.923880j, -0.405241 + 0.914210j, -0.427555 + 0.903989j, -0.449611 + 0.893224j, -0.471397 + 0.881921j, -0.492898 + 0.870087j, -0.514103 + 0.857729j, -0.534998 + 0.844854j, -0.555570 + 0.831470j, -0.575808 + 0.817585j, -0.595699 + 0.803208j, -0.615232 + 0.788346j, -0.634393 + 0.773010j, -0.653173 + 0.757209j, -0.671559 + 0.740951j, -0.689541 + 0.724247j, -0.707107 + 0.707107j, -0.724247 + 0.689541j, -0.740951 + 0.671559j, -0.757209 + 0.653173j, -0.773010 + 0.634393j, -0.788346 + 0.615232j, -0.803208 + 0.595699j, -0.817585 + 0.575808j, -0.831470 + 0.555570j, -0.844854 + 0.534998j, -0.857729 + 0.514103j, -0.870087 + 0.492898j, -0.881921 + 0.471397j, -0.893224 + 0.449611j, -0.903989 + 0.427555j, -0.914210 + 0.405241j, -0.923880 + 0.382683j, -0.932993 + 0.359895j, -0.941544 + 0.336890j, -0.949528 + 0.313682j, -0.956940 + 0.290285j, -0.963776 + 0.266713j, -0.970031 + 0.242980j, -0.975702 + 0.219101j, -0.980785 + 0.195090j, -0.985278 + 0.170962j, -0.989177 + 0.146730j, -0.992480 + 0.122411j, -0.995185 + 0.098017j, -0.997290 + 0.073565j, -0.998795 + 0.049068j, -0.999699 + 0.024541j, -1.000000 + 0.000000j, -0.999699 + -0.024541j, -0.998795 + -0.049068j, -0.997290 + -0.073565j, -0.995185 + -0.098017j, -0.992480 + -0.122411j, -0.989177 + -0.146730j, -0.985278 + -0.170962j, -0.980785 + -0.195090j, -0.975702 + -0.219101j, -0.970031 + -0.242980j, -0.963776 + -0.266713j, -0.956940 + -0.290285j, -0.949528 + -0.313682j, -0.941544 + -0.336890j, -0.932993 + -0.359895j, -0.923880 + -0.382683j, -0.914210 + -0.405241j, -0.903989 + -0.427555j, -0.893224 + -0.449611j, -0.881921 + -0.471397j, -0.870087 + -0.492898j, -0.857729 + -0.514103j, -0.844854 + -0.534998j, -0.831470 + -0.555570j, -0.817585 + -0.575808j, -0.803208 + -0.595699j, -0.788346 + -0.615232j, -0.773010 + -0.634393j, -0.757209 + -0.653173j, -0.740951 + -0.671559j, -0.724247 + -0.689541j, -0.707107 + -0.707107j, -0.689541 + -0.724247j, -0.671559 + -0.740951j, -0.653173 + -0.757209j, -0.634393 + -0.773010j, -0.615232 + -0.788346j, -0.595699 + -0.803208j, -0.575808 + -0.817585j, -0.555570 + -0.831470j, -0.534998 + -0.844854j, -0.514103 + -0.857729j, -0.492898 + -0.870087j, -0.471397 + -0.881921j, -0.449611 + -0.893224j, -0.427555 + -0.903989j, -0.405241 + -0.914210j, -0.382683 + -0.923880j, -0.359895 + -0.932993j, -0.336890 + -0.941544j, -0.313682 + -0.949528j, -0.290285 + -0.956940j, -0.266713 + -0.963776j, -0.242980 + -0.970031j, -0.219101 + -0.975702j, -0.195090 + -0.980785j, -0.170962 + -0.985278j, -0.146730 + -0.989177j, -0.122411 + -0.992480j, -0.098017 + -0.995185j, -0.073565 + -0.997290j, -0.049068 + -0.998795j, -0.024541 + -0.999699j, -0.000000 + -1.000000j, 0.024541 + -0.999699j, 0.049068 + -0.998795j, 0.073565 + -0.997290j, 0.098017 + -0.995185j, 0.122411 + -0.992480j, 0.146730 + -0.989177j, 0.170962 + -0.985278j, 0.195090 + -0.980785j, 0.219101 + -0.975702j, 0.242980 + -0.970031j, 0.266713 + -0.963776j, 0.290285 + -0.956940j, 0.313682 + -0.949528j, 0.336890 + -0.941544j, 0.359895 + -0.932993j, 0.382683 + -0.923880j, 0.405241 + -0.914210j, 0.427555 + -0.903989j, 0.449611 + -0.893224j, 0.471397 + -0.881921j, 0.492898 + -0.870087j, 0.514103 + -0.857729j, 0.534998 + -0.844854j, 0.555570 + -0.831470j, 0.575808 + -0.817585j, 0.595699 + -0.803208j, 0.615232 + -0.788346j, 0.634393 + -0.773010j, 0.653173 + -0.757209j, 0.671559 + -0.740951j, 0.689541 + -0.724247j, 0.707107 + -0.707107j, 0.724247 + -0.689541j, 0.740951 + -0.671559j, 0.757209 + -0.653173j, 0.773010 + -0.634393j, 0.788346 + -0.615232j, 0.803208 + -0.595699j, 0.817585 + -0.575808j, 0.831470 + -0.555570j, 0.844854 + -0.534998j, 0.857729 + -0.514103j, 0.870087 + -0.492898j, 0.881921 + -0.471397j, 0.893224 + -0.449611j, 0.903989 + -0.427555j, 0.914210 + -0.405241j, 0.923880 + -0.382683j, 0.932993 + -0.359895j, 0.941544 + -0.336890j, 0.949528 + -0.313682j, 0.956940 + -0.290285j, 0.963776 + -0.266713j, 0.970031 + -0.242980j, 0.975702 + -0.219101j, 0.980785 + -0.195090j, 0.985278 + -0.170962j, 0.989177 + -0.146730j, 0.992480 + -0.122411j, 0.995185 + -0.098017j, 0.997290 + -0.073565j, 0.998795 + -0.049068j, 0.999699 + -0.024541j], dtype=numpy.complex64)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ssl</value></param>
<param><key>value</key><value>len(ss)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>syml</value></param>
<param><key>value</key><value>syms.size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>syms</value></param>
<param><key>value</key><value>numpy.append(numpy.append(numpy.append(ss,numpy.tile(s,2)),es),numpy.zeros([], dtype=numpy.complex64))</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>freq</key><value>f</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>comment</key><value>SAMPLE ALIGN SIGNAL
SOURCE AND USRP</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>rate * 60 * 5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0</value></param>
<param><key>high</key><value>0.08</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.001</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_0</value></param>
<param><key>high</key><value>0.02</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.001</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0</value></param>
<param><key>access_code</key><value>0000000000000001</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>START</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0_0</value></param>
<param><key>access_code</key><value>0000000000000001</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>END</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>pdu_utils_pdu_to_bursts_X</key>
<param><key>id</key><value>pdu_utils_pdu_to_bursts_X_0</value></param>
<param><key>early_behavior</key><value>pdu_utils.EARLY_BURST_BEHAVIOR__APPEND</value></param>
<param><key>type</key><value>c</value></param>
<param><key>depth</key><value>64</value></param>
</block>
<block>
<key>pdu_utils_tag_message_trigger_X</key>
<param><key>id</key><value>pdu_utils_tag_message_trigger_X_0</value></param>
<param><key>arm_key</key><value>pmt.PMT_NIL</value></param>
<param><key>showport</key><value>False</value></param>
<param><key>delay_time</key><value>0</value></param>
<param><key>holdoff</key><value>0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.make_dict(), pmt.to_pmt(numpy.conj(syms)))</value></param>
<param><key>tpdu_mode</key><value>False</value></param>
<param><key>samp_rate</key><value>rate</value></param>
<param><key>start_time</key><value>0</value></param>
<param><key>trig_key</key><value>pmt.intern("START")</value></param>
<param><key>type</key><value>f</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Trigger Magnitude</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>Trigger Threshold</value></param>
<param><key>style2</key><value>2</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>label3</key><value>USRP Magnitude</value></param>
<param><key>color4</key><value>"red"</value></param>
<param><key>label4</key><value>USRP Threshold</value></param>
<param><key>style4</key><value>2</value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value></value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>size</key><value>rate / f</value></param>
<param><key>srate</key><value>rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_delay</key><value>0.005</value></param>
<param><key>tr_level</key><value>0.08</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>ymax</key><value>1.25</value></param>
<param><key>ymin</key><value>-0.25</value></param>
</block>
<block>
<key>timing_utils_edge_distance</key>
<param><key>id</key><value>timing_utils_edge_distance_0</value></param>
<param><key>rate</key><value>rate</value></param>
</block>
<block>
<key>timing_utils_thresh_trigger_f</key>
<param><key>id</key><value>timing_utils_thresh_trigger_f_0</value></param>
<param><key>length</key><value>2</value></param>
<param><key>hi</key><value>0.1</value></param>
<param><key>low</key><value>0.01</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>80</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>60</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>args</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>usrp_mag</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>trig</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>trig_mag</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_5_0</value></param>
<param><key>stream_id</key><value>usrp_t</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_5_0_0</value></param>
<param><key>stream_id</key><value>trig_t</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>usrp_mag</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>usrp_t</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0</value></param>
<param><key>stream_id</key><value>trig_t</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>trig</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>trig_mag</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_6</value></param>
<param><key>stream_id</key><value>usrp_t</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_7</value></param>
<param><key>stream_id</key><value>trig_t</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_9</value></param>
<param><key>stream_id</key><value>trig_mag</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5050</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5050</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>timing_utils_edge_distance_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0</source_block_id><sink_block_id>virtual_sink_5_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_0</source_block_id><sink_block_id>virtual_sink_5_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_to_bursts_X_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdu_utils_tag_message_trigger_X_0</source_block_id><sink_block_id>pdu_utils_pdu_to_bursts_X_0</sink_block_id><source_key>msg</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>pdu_utils_tag_message_trigger_X_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>timing_utils_thresh_trigger_f_0</source_block_id><sink_block_id>pdu_utils_tag_message_trigger_X_0</sink_block_id><source_key>trig</source_key><sink_key>ctrl</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>pdu_utils_tag_message_trigger_X_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_6</source_block_id><sink_block_id>blocks_float_to_char_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_7</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_9</source_block_id><sink_block_id>timing_utils_thresh_trigger_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>pdu_utils_pdu_to_bursts_X_0</sink_block_id><source_key>out</source_key><sink_key>bursts</sink_key></connection>
</flow_graph>
