options:
  parameters:
    author: J. Gilbert
    description: evaluates loopback latency
    generate_options: qt_gui
    id: uhd_loopback_latency_test
    output_language: python
    realtime_scheduling: '1'
    title: UHD Loopback Latency Test
  states: {}

blocks:
- name: args
  id: variable
  parameters:
    value: '"recv_frame_size=256, num_recv_frames=256, send_frame_size=256, num_send_frames=256"'
  states: {state: disabled}
- name: args_0
  id: variable
  parameters:
    value: '"recv_frame_size=64, num_recv_frames=1024, send_frame_size=64, num_send_frames=1024"'
  states: {state: disabled}
- name: args_1
  id: variable
  parameters:
    value: '""'
  states: {}
- name: el
  id: variable
  parameters:
    value: len(es)
  states: {}
- name: es
  id: variable
  parameters:
    comment: End Symbols
    value: numpy.array([1.000000 + -0.000000j, 0.999699 + 0.024541j, 0.998795 + 0.049068j, 0.997290 + 0.073565j, 0.995185 + 0.098017j, 0.992480 + 0.122411j, 0.989177 + 0.146730j, 0.985278 + 0.170962j, 0.980785 + 0.195090j, 0.975702 + 0.219101j, 0.970031 + 0.242980j, 0.963776 + 0.266713j, 0.956940 + 0.290285j, 0.949528 + 0.313682j, 0.941544 + 0.336890j, 0.932993 + 0.359895j, 0.923880 + 0.382683j, 0.914210 + 0.405241j, 0.903989 + 0.427555j, 0.893224 + 0.449611j, 0.881921 + 0.471397j, 0.870087 + 0.492898j, 0.857729 + 0.514103j, 0.844854 + 0.534998j, 0.831470 + 0.555570j, 0.817585 + 0.575808j, 0.803208 + 0.595699j, 0.788346 + 0.615232j, 0.773010 + 0.634393j, 0.757209 + 0.653173j, 0.740951 + 0.671559j, 0.724247 + 0.689541j, 0.707107 + 0.707107j, 0.689541 + 0.724247j, 0.671559 + 0.740951j, 0.653173 + 0.757209j, 0.634393 + 0.773010j, 0.615232 + 0.788346j, 0.595699 + 0.803208j, 0.575808 + 0.817585j, 0.555570 + 0.831470j, 0.534998 + 0.844854j, 0.514103 + 0.857729j, 0.492898 + 0.870087j, 0.471397 + 0.881921j, 0.449611 + 0.893224j, 0.427555 + 0.903989j, 0.405241 + 0.914210j, 0.382683 + 0.923880j, 0.359895 + 0.932993j, 0.336890 + 0.941544j, 0.313682 + 0.949528j, 0.290285 + 0.956940j, 0.266713 + 0.963776j, 0.242980 + 0.970031j, 0.219101 + 0.975702j, 0.195090 + 0.980785j, 0.170962 + 0.985278j, 0.146730 + 0.989177j, 0.122411 + 0.992480j, 0.098017 + 0.995185j, 0.073565 + 0.997290j, 0.049068 + 0.998795j, 0.024541 + 0.999699j, 0.000000 + 1.000000j, -0.024541 + 0.999699j, -0.049068 + 0.998795j, -0.073565 + 0.997290j, -0.098017 + 0.995185j, -0.122411 + 0.992480j, -0.146730 + 0.989177j, -0.170962 + 0.985278j, -0.195090 + 0.980785j, -0.219101 + 0.975702j, -0.242980 + 0.970031j, -0.266713 + 0.963776j, -0.290285 + 0.956940j, -0.313682 + 0.949528j, -0.336890 + 0.941544j, -0.359895 + 0.932993j, -0.382683 + 0.923880j, -0.405241 + 0.914210j, -0.427555 + 0.903989j, -0.449611 + 0.893224j, -0.471397 + 0.881921j, -0.492898 + 0.870087j, -0.514103 + 0.857729j, -0.534998 + 0.844854j, -0.555570 + 0.831470j, -0.575808 + 0.817585j, -0.595699 + 0.803208j, -0.615232 + 0.788346j, -0.634393 + 0.773010j, -0.653173 + 0.757209j, -0.671559 + 0.740951j, -0.689541 + 0.724247j, -0.707107 + 0.707107j, -0.724247 + 0.689541j, -0.740951 + 0.671559j, -0.757209 + 0.653173j, -0.773010 + 0.634393j, -0.788346 + 0.615232j, -0.803208 + 0.595699j, -0.817585 + 0.575808j, -0.831470 + 0.555570j, -0.844854 + 0.534998j, -0.857729 + 0.514103j, -0.870087 + 0.492898j, -0.881921 + 0.471397j, -0.893224 + 0.449611j, -0.903989 + 0.427555j, -0.914210 + 0.405241j, -0.923880 + 0.382683j, -0.932993 + 0.359895j, -0.941544 + 0.336890j, -0.949528 + 0.313682j, -0.956940 + 0.290285j, -0.963776 + 0.266713j, -0.970031 + 0.242980j, -0.975702 + 0.219101j, -0.980785 + 0.195090j, -0.985278 + 0.170962j, -0.989177 + 0.146730j, -0.992480 + 0.122411j, -0.995185 + 0.098017j, -0.997290 + 0.073565j, -0.998795 + 0.049068j, -0.999699 + 0.024541j, -1.000000 + 0.000000j, -0.999699 + -0.024541j, -0.998795 + -0.049068j, -0.997290 + -0.073565j, -0.995185 + -0.098017j, -0.992480 + -0.122411j, -0.989177 + -0.146730j, -0.985278 + -0.170962j, -0.980785 + -0.195090j, -0.975702 + -0.219101j, -0.970031 + -0.242980j, -0.963776 + -0.266713j, -0.956940 + -0.290285j, -0.949528 + -0.313682j, -0.941544 + -0.336890j, -0.932993 + -0.359895j, -0.923880 + -0.382683j, -0.914210 + -0.405241j, -0.903989 + -0.427555j, -0.893224 + -0.449611j, -0.881921 + -0.471397j, -0.870087 + -0.492898j, -0.857729 + -0.514103j, -0.844854 + -0.534998j, -0.831470 + -0.555570j, -0.817585 + -0.575808j, -0.803208 + -0.595699j, -0.788346 + -0.615232j, -0.773010 + -0.634393j, -0.757209 + -0.653173j, -0.740951 + -0.671559j, -0.724247 + -0.689541j, -0.707107 + -0.707107j, -0.689541 + -0.724247j, -0.671559 + -0.740951j, -0.653173 + -0.757209j, -0.634393 + -0.773010j, -0.615232 + -0.788346j, -0.595699 + -0.803208j, -0.575808 + -0.817585j, -0.555570 + -0.831470j, -0.534998 + -0.844854j, -0.514103 + -0.857729j, -0.492898 + -0.870087j, -0.471397 + -0.881921j, -0.449611 + -0.893224j, -0.427555 + -0.903989j, -0.405241 + -0.914210j, -0.382683 + -0.923880j, -0.359895 + -0.932993j, -0.336890 + -0.941544j, -0.313682 + -0.949528j, -0.290285 + -0.956940j, -0.266713 + -0.963776j, -0.242980 + -0.970031j, -0.219101 + -0.975702j, -0.195090 + -0.980785j, -0.170962 + -0.985278j, -0.146730 + -0.989177j, -0.122411 + -0.992480j, -0.098017 + -0.995185j, -0.073565 + -0.997290j, -0.049068 + -0.998795j, -0.024541 + -0.999699j, 0.000000 + -1.000000j, 0.024534 + -0.999398j, 0.049009 + -0.997592j, 0.073365 + -0.994588j, 0.097545 + -0.990393j, 0.121490 + -0.985016j, 0.145142 + -0.978470j, 0.168445 + -0.970772j, 0.191342 + -0.961940j, 0.213778 + -0.951995j, 0.235698 + -0.940961j, 0.257051 + -0.928864j, 0.277785 + -0.915735j, 0.297850 + -0.901604j, 0.317197 + -0.886505j, 0.335779 + -0.870476j, 0.353553 + -0.853553j, 0.370476 + -0.835779j, 0.386505 + -0.817197j, 0.401604 + -0.797850j, 0.415735 + -0.777785j, 0.428864 + -0.757051j, 0.440961 + -0.735698j, 0.451995 + -0.713778j, 0.461940 + -0.691342j, 0.470772 + -0.668445j, 0.478470 + -0.645142j, 0.485016 + -0.621490j, 0.490393 + -0.597545j, 0.494588 + -0.573365j, 0.497592 + -0.549009j, 0.499398 + -0.524534j, 0.500000 + -0.500000j, 0.499398 + -0.475466j, 0.497592 + -0.450991j, 0.494588 + -0.426635j, 0.490393 + -0.402455j, 0.485016 + -0.378510j, 0.478470 + -0.354858j, 0.470772 + -0.331555j, 0.461940 + -0.308658j, 0.451995 + -0.286222j, 0.440961 + -0.264302j, 0.428864 + -0.242949j, 0.415735 + -0.222215j, 0.401604 + -0.202150j, 0.386505 + -0.182803j, 0.370476 + -0.164221j, 0.353553 + -0.146447j, 0.335779 + -0.129524j, 0.317197 + -0.113495j, 0.297850 + -0.098396j, 0.277785 + -0.084265j, 0.257051 + -0.071136j, 0.235698 + -0.059039j, 0.213778 + -0.048005j, 0.191342 + -0.038060j, 0.168445 + -0.029228j, 0.145142 + -0.021530j, 0.121490 + -0.014984j, 0.097545 + -0.009607j, 0.073365 + -0.005412j, 0.049009 + -0.002408j, 0.024534 + -0.000602j], dtype=numpy.complex64)
  states: {}
- name: f
  id: variable
  parameters:
    value: '25'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: n
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: s
  id: variable
  parameters:
    comment: Symbols
    value: numpy.array([1.000000 + -0.000000j, 0.999699 + 0.024541j, 0.998795 + 0.049068j, 0.997290 + 0.073565j, 0.995185 + 0.098017j, 0.992480 + 0.122411j, 0.989177 + 0.146730j, 0.985278 + 0.170962j, 0.980785 + 0.195090j, 0.975702 + 0.219101j, 0.970031 + 0.242980j, 0.963776 + 0.266713j, 0.956940 + 0.290285j, 0.949528 + 0.313682j, 0.941544 + 0.336890j, 0.932993 + 0.359895j, 0.923880 + 0.382683j, 0.914210 + 0.405241j, 0.903989 + 0.427555j, 0.893224 + 0.449611j, 0.881921 + 0.471397j, 0.870087 + 0.492898j, 0.857729 + 0.514103j, 0.844854 + 0.534998j, 0.831470 + 0.555570j, 0.817585 + 0.575808j, 0.803208 + 0.595699j, 0.788346 + 0.615232j, 0.773010 + 0.634393j, 0.757209 + 0.653173j, 0.740951 + 0.671559j, 0.724247 + 0.689541j, 0.707107 + 0.707107j, 0.689541 + 0.724247j, 0.671559 + 0.740951j, 0.653173 + 0.757209j, 0.634393 + 0.773010j, 0.615232 + 0.788346j, 0.595699 + 0.803208j, 0.575808 + 0.817585j, 0.555570 + 0.831470j, 0.534998 + 0.844854j, 0.514103 + 0.857729j, 0.492898 + 0.870087j, 0.471397 + 0.881921j, 0.449611 + 0.893224j, 0.427555 + 0.903989j, 0.405241 + 0.914210j, 0.382683 + 0.923880j, 0.359895 + 0.932993j, 0.336890 + 0.941544j, 0.313682 + 0.949528j, 0.290285 + 0.956940j, 0.266713 + 0.963776j, 0.242980 + 0.970031j, 0.219101 + 0.975702j, 0.195090 + 0.980785j, 0.170962 + 0.985278j, 0.146730 + 0.989177j, 0.122411 + 0.992480j, 0.098017 + 0.995185j, 0.073565 + 0.997290j, 0.049068 + 0.998795j, 0.024541 + 0.999699j, 0.000000 + 1.000000j, -0.024541 + 0.999699j, -0.049068 + 0.998795j, -0.073565 + 0.997290j, -0.098017 + 0.995185j, -0.122411 + 0.992480j, -0.146730 + 0.989177j, -0.170962 + 0.985278j, -0.195090 + 0.980785j, -0.219101 + 0.975702j, -0.242980 + 0.970031j, -0.266713 + 0.963776j, -0.290285 + 0.956940j, -0.313682 + 0.949528j, -0.336890 + 0.941544j, -0.359895 + 0.932993j, -0.382683 + 0.923880j, -0.405241 + 0.914210j, -0.427555 + 0.903989j, -0.449611 + 0.893224j, -0.471397 + 0.881921j, -0.492898 + 0.870087j, -0.514103 + 0.857729j, -0.534998 + 0.844854j, -0.555570 + 0.831470j, -0.575808 + 0.817585j, -0.595699 + 0.803208j, -0.615232 + 0.788346j, -0.634393 + 0.773010j, -0.653173 + 0.757209j, -0.671559 + 0.740951j, -0.689541 + 0.724247j, -0.707107 + 0.707107j, -0.724247 + 0.689541j, -0.740951 + 0.671559j, -0.757209 + 0.653173j, -0.773010 + 0.634393j, -0.788346 + 0.615232j, -0.803208 + 0.595699j, -0.817585 + 0.575808j, -0.831470 + 0.555570j, -0.844854 + 0.534998j, -0.857729 + 0.514103j, -0.870087 + 0.492898j, -0.881921 + 0.471397j, -0.893224 + 0.449611j, -0.903989 + 0.427555j, -0.914210 + 0.405241j, -0.923880 + 0.382683j, -0.932993 + 0.359895j, -0.941544 + 0.336890j, -0.949528 + 0.313682j, -0.956940 + 0.290285j, -0.963776 + 0.266713j, -0.970031 + 0.242980j, -0.975702 + 0.219101j, -0.980785 + 0.195090j, -0.985278 + 0.170962j, -0.989177 + 0.146730j, -0.992480 + 0.122411j, -0.995185 + 0.098017j, -0.997290 + 0.073565j, -0.998795 + 0.049068j, -0.999699 + 0.024541j, -1.000000 + 0.000000j, -0.999699 + -0.024541j, -0.998795 + -0.049068j, -0.997290 + -0.073565j, -0.995185 + -0.098017j, -0.992480 + -0.122411j, -0.989177 + -0.146730j, -0.985278 + -0.170962j, -0.980785 + -0.195090j, -0.975702 + -0.219101j, -0.970031 + -0.242980j, -0.963776 + -0.266713j, -0.956940 + -0.290285j, -0.949528 + -0.313682j, -0.941544 + -0.336890j, -0.932993 + -0.359895j, -0.923880 + -0.382683j, -0.914210 + -0.405241j, -0.903989 + -0.427555j, -0.893224 + -0.449611j, -0.881921 + -0.471397j, -0.870087 + -0.492898j, -0.857729 + -0.514103j, -0.844854 + -0.534998j, -0.831470 + -0.555570j, -0.817585 + -0.575808j, -0.803208 + -0.595699j, -0.788346 + -0.615232j, -0.773010 + -0.634393j, -0.757209 + -0.653173j, -0.740951 + -0.671559j, -0.724247 + -0.689541j, -0.707107 + -0.707107j, -0.689541 + -0.724247j, -0.671559 + -0.740951j, -0.653173 + -0.757209j, -0.634393 + -0.773010j, -0.615232 + -0.788346j, -0.595699 + -0.803208j, -0.575808 + -0.817585j, -0.555570 + -0.831470j, -0.534998 + -0.844854j, -0.514103 + -0.857729j, -0.492898 + -0.870087j, -0.471397 + -0.881921j, -0.449611 + -0.893224j, -0.427555 + -0.903989j, -0.405241 + -0.914210j, -0.382683 + -0.923880j, -0.359895 + -0.932993j, -0.336890 + -0.941544j, -0.313682 + -0.949528j, -0.290285 + -0.956940j, -0.266713 + -0.963776j, -0.242980 + -0.970031j, -0.219101 + -0.975702j, -0.195090 + -0.980785j, -0.170962 + -0.985278j, -0.146730 + -0.989177j, -0.122411 + -0.992480j, -0.098017 + -0.995185j, -0.073565 + -0.997290j, -0.049068 + -0.998795j, -0.024541 + -0.999699j, -0.000000 + -1.000000j, 0.024541 + -0.999699j, 0.049068 + -0.998795j, 0.073565 + -0.997290j, 0.098017 + -0.995185j, 0.122411 + -0.992480j, 0.146730 + -0.989177j, 0.170962 + -0.985278j, 0.195090 + -0.980785j, 0.219101 + -0.975702j, 0.242980 + -0.970031j, 0.266713 + -0.963776j, 0.290285 + -0.956940j, 0.313682 + -0.949528j, 0.336890 + -0.941544j, 0.359895 + -0.932993j, 0.382683 + -0.923880j, 0.405241 + -0.914210j, 0.427555 + -0.903989j, 0.449611 + -0.893224j, 0.471397 + -0.881921j, 0.492898 + -0.870087j, 0.514103 + -0.857729j, 0.534998 + -0.844854j, 0.555570 + -0.831470j, 0.575808 + -0.817585j, 0.595699 + -0.803208j, 0.615232 + -0.788346j, 0.634393 + -0.773010j, 0.653173 + -0.757209j, 0.671559 + -0.740951j, 0.689541 + -0.724247j, 0.707107 + -0.707107j, 0.724247 + -0.689541j, 0.740951 + -0.671559j, 0.757209 + -0.653173j, 0.773010 + -0.634393j, 0.788346 + -0.615232j, 0.803208 + -0.595699j, 0.817585 + -0.575808j, 0.831470 + -0.555570j, 0.844854 + -0.534998j, 0.857729 + -0.514103j, 0.870087 + -0.492898j, 0.881921 + -0.471397j, 0.893224 + -0.449611j, 0.903989 + -0.427555j, 0.914210 + -0.405241j, 0.923880 + -0.382683j, 0.932993 + -0.359895j, 0.941544 + -0.336890j, 0.949528 + -0.313682j, 0.956940 + -0.290285j, 0.963776 + -0.266713j, 0.970031 + -0.242980j, 0.975702 + -0.219101j, 0.980785 + -0.195090j, 0.985278 + -0.170962j, 0.989177 + -0.146730j, 0.992480 + -0.122411j, 0.995185 + -0.098017j, 0.997290 + -0.073565j, 0.998795 + -0.049068j, 0.999699 + -0.024541j], dtype=numpy.complex64)
  states: {}
- name: sl
  id: variable
  parameters:
    value: len(s)
  states: {}
- name: ss
  id: variable
  parameters:
    comment: Start Symbols
    value: numpy.array([0.049068 + 0.000000j, 0.097988 + 0.002405j, 0.146554 + 0.007200j, 0.194562 + 0.014352j, 0.241810 + 0.023816j, 0.288102 + 0.035534j, 0.333244 + 0.049432j, 0.377049 + 0.065424j, 0.419340 + 0.083412j, 0.459943 + 0.103284j, 0.498696 + 0.124917j, 0.535445 + 0.148178j, 0.570049 + 0.172922j, 0.602374 + 0.198998j, 0.632302 + 0.226241j, 0.659726 + 0.254484j, 0.684550 + 0.283550j, 0.706694 + 0.313256j, 0.726091 + 0.343415j, 0.742689 + 0.373838j, 0.756449 + 0.404330j, 0.767348 + 0.434697j, 0.775377 + 0.464743j, 0.780543 + 0.494273j, 0.782865 + 0.523094j, 0.782380 + 0.551014j, 0.779136 + 0.577847j, 0.773199 + 0.603410j, 0.764644 + 0.627527j, 0.753563 + 0.650028j, 0.740059 + 0.670750j, 0.724247 + 0.689541j, 0.707107 + 0.707107j, 0.689541 + 0.724247j, 0.671559 + 0.740951j, 0.653173 + 0.757209j, 0.634393 + 0.773010j, 0.615232 + 0.788346j, 0.595699 + 0.803208j, 0.575808 + 0.817585j, 0.555570 + 0.831470j, 0.534998 + 0.844854j, 0.514103 + 0.857729j, 0.492898 + 0.870087j, 0.471397 + 0.881921j, 0.449611 + 0.893224j, 0.427555 + 0.903989j, 0.405241 + 0.914210j, 0.382683 + 0.923880j, 0.359895 + 0.932993j, 0.336890 + 0.941544j, 0.313682 + 0.949528j, 0.290285 + 0.956940j, 0.266713 + 0.963776j, 0.242980 + 0.970031j, 0.219101 + 0.975702j, 0.195090 + 0.980785j, 0.170962 + 0.985278j, 0.146730 + 0.989177j, 0.122411 + 0.992480j, 0.098017 + 0.995185j, 0.073565 + 0.997290j, 0.049068 + 0.998795j, 0.024541 + 0.999699j, 0.000000 + 1.000000j, -0.024541 + 0.999699j, -0.049068 + 0.998795j, -0.073565 + 0.997290j, -0.098017 + 0.995185j, -0.122411 + 0.992480j, -0.146730 + 0.989177j, -0.170962 + 0.985278j, -0.195090 + 0.980785j, -0.219101 + 0.975702j, -0.242980 + 0.970031j, -0.266713 + 0.963776j, -0.290285 + 0.956940j, -0.313682 + 0.949528j, -0.336890 + 0.941544j, -0.359895 + 0.932993j, -0.382683 + 0.923880j, -0.405241 + 0.914210j, -0.427555 + 0.903989j, -0.449611 + 0.893224j, -0.471397 + 0.881921j, -0.492898 + 0.870087j, -0.514103 + 0.857729j, -0.534998 + 0.844854j, -0.555570 + 0.831470j, -0.575808 + 0.817585j, -0.595699 + 0.803208j, -0.615232 + 0.788346j, -0.634393 + 0.773010j, -0.653173 + 0.757209j, -0.671559 + 0.740951j, -0.689541 + 0.724247j, -0.707107 + 0.707107j, -0.724247 + 0.689541j, -0.740951 + 0.671559j, -0.757209 + 0.653173j, -0.773010 + 0.634393j, -0.788346 + 0.615232j, -0.803208 + 0.595699j, -0.817585 + 0.575808j, -0.831470 + 0.555570j, -0.844854 + 0.534998j, -0.857729 + 0.514103j, -0.870087 + 0.492898j, -0.881921 + 0.471397j, -0.893224 + 0.449611j, -0.903989 + 0.427555j, -0.914210 + 0.405241j, -0.923880 + 0.382683j, -0.932993 + 0.359895j, -0.941544 + 0.336890j, -0.949528 + 0.313682j, -0.956940 + 0.290285j, -0.963776 + 0.266713j, -0.970031 + 0.242980j, -0.975702 + 0.219101j, -0.980785 + 0.195090j, -0.985278 + 0.170962j, -0.989177 + 0.146730j, -0.992480 + 0.122411j, -0.995185 + 0.098017j, -0.997290 + 0.073565j, -0.998795 + 0.049068j, -0.999699 + 0.024541j, -1.000000 + 0.000000j, -0.999699 + -0.024541j, -0.998795 + -0.049068j, -0.997290 + -0.073565j, -0.995185 + -0.098017j, -0.992480 + -0.122411j, -0.989177 + -0.146730j, -0.985278 + -0.170962j, -0.980785 + -0.195090j, -0.975702 + -0.219101j, -0.970031 + -0.242980j, -0.963776 + -0.266713j, -0.956940 + -0.290285j, -0.949528 + -0.313682j, -0.941544 + -0.336890j, -0.932993 + -0.359895j, -0.923880 + -0.382683j, -0.914210 + -0.405241j, -0.903989 + -0.427555j, -0.893224 + -0.449611j, -0.881921 + -0.471397j, -0.870087 + -0.492898j, -0.857729 + -0.514103j, -0.844854 + -0.534998j, -0.831470 + -0.555570j, -0.817585 + -0.575808j, -0.803208 + -0.595699j, -0.788346 + -0.615232j, -0.773010 + -0.634393j, -0.757209 + -0.653173j, -0.740951 + -0.671559j, -0.724247 + -0.689541j, -0.707107 + -0.707107j, -0.689541 + -0.724247j, -0.671559 + -0.740951j, -0.653173 + -0.757209j, -0.634393 + -0.773010j, -0.615232 + -0.788346j, -0.595699 + -0.803208j, -0.575808 + -0.817585j, -0.555570 + -0.831470j, -0.534998 + -0.844854j, -0.514103 + -0.857729j, -0.492898 + -0.870087j, -0.471397 + -0.881921j, -0.449611 + -0.893224j, -0.427555 + -0.903989j, -0.405241 + -0.914210j, -0.382683 + -0.923880j, -0.359895 + -0.932993j, -0.336890 + -0.941544j, -0.313682 + -0.949528j, -0.290285 + -0.956940j, -0.266713 + -0.963776j, -0.242980 + -0.970031j, -0.219101 + -0.975702j, -0.195090 + -0.980785j, -0.170962 + -0.985278j, -0.146730 + -0.989177j, -0.122411 + -0.992480j, -0.098017 + -0.995185j, -0.073565 + -0.997290j, -0.049068 + -0.998795j, -0.024541 + -0.999699j, -0.000000 + -1.000000j, 0.024541 + -0.999699j, 0.049068 + -0.998795j, 0.073565 + -0.997290j, 0.098017 + -0.995185j, 0.122411 + -0.992480j, 0.146730 + -0.989177j, 0.170962 + -0.985278j, 0.195090 + -0.980785j, 0.219101 + -0.975702j, 0.242980 + -0.970031j, 0.266713 + -0.963776j, 0.290285 + -0.956940j, 0.313682 + -0.949528j, 0.336890 + -0.941544j, 0.359895 + -0.932993j, 0.382683 + -0.923880j, 0.405241 + -0.914210j, 0.427555 + -0.903989j, 0.449611 + -0.893224j, 0.471397 + -0.881921j, 0.492898 + -0.870087j, 0.514103 + -0.857729j, 0.534998 + -0.844854j, 0.555570 + -0.831470j, 0.575808 + -0.817585j, 0.595699 + -0.803208j, 0.615232 + -0.788346j, 0.634393 + -0.773010j, 0.653173 + -0.757209j, 0.671559 + -0.740951j, 0.689541 + -0.724247j, 0.707107 + -0.707107j, 0.724247 + -0.689541j, 0.740951 + -0.671559j, 0.757209 + -0.653173j, 0.773010 + -0.634393j, 0.788346 + -0.615232j, 0.803208 + -0.595699j, 0.817585 + -0.575808j, 0.831470 + -0.555570j, 0.844854 + -0.534998j, 0.857729 + -0.514103j, 0.870087 + -0.492898j, 0.881921 + -0.471397j, 0.893224 + -0.449611j, 0.903989 + -0.427555j, 0.914210 + -0.405241j, 0.923880 + -0.382683j, 0.932993 + -0.359895j, 0.941544 + -0.336890j, 0.949528 + -0.313682j, 0.956940 + -0.290285j, 0.963776 + -0.266713j, 0.970031 + -0.242980j, 0.975702 + -0.219101j, 0.980785 + -0.195090j, 0.985278 + -0.170962j, 0.989177 + -0.146730j, 0.992480 + -0.122411j, 0.995185 + -0.098017j, 0.997290 + -0.073565j, 0.998795 + -0.049068j, 0.999699 + -0.024541j], dtype=numpy.complex64)
  states: {}
- name: ssl
  id: variable
  parameters:
    value: len(ss)
  states: {}
- name: syml
  id: variable
  parameters:
    value: syms.size
  states: {}
- name: syms
  id: variable
  parameters:
    value: numpy.append(numpy.append(numpy.append(ss,numpy.tile(s,2)),es),numpy.zeros([], dtype=numpy.complex64))
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: f
    offset: '0'
    phase: '0'
    samp_rate: rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: |-
      SAMPLE ALIGN SIGNAL
      SOURCE AND USRP
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: rate * 60 * 5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.08'
    init: '0'
    low: '0.001'
  states: {}
- name: blocks_threshold_ff_0_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.02'
    init: '0'
    low: '0.001'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '0000000000000001'
    tagname: START
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '0000000000000001'
    tagname: END
    threshold: '0'
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pdu_utils_pdu_to_bursts_X_0
  id: pdu_utils_pdu_to_bursts_X
  parameters:
    depth: '64'
    early_behavior: pdu_utils.EARLY_BURST_BEHAVIOR__APPEND
    type: c
  states: {}
- name: pdu_utils_tag_message_trigger_X_0
  id: pdu_utils_tag_message_trigger_X
  parameters:
    arm_key: pmt.PMT_NIL
    delay_time: '0'
    holdoff: '0'
    msg: pmt.cons(pmt.make_dict(), pmt.to_pmt(numpy.conj(syms)))
    samp_rate: rate
    showport: 'False'
    start_time: '0'
    tpdu_mode: 'False'
    trig_key: pmt.intern("START")
    type: f
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Trigger Magnitude
    label2: Trigger Threshold
    label3: USRP Magnitude
    label4: USRP Threshold
    label5: ''
    nconnections: '5'
    size: int(rate / f)
    srate: rate
    style2: '2'
    style4: '2'
    tr_chan: '1'
    tr_delay: '0.005'
    tr_level: '0.08'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.01'
    ymax: '1.25'
    ymin: '-0.25'
  states: {}
- name: timing_utils_edge_distance_0
  id: timing_utils_edge_distance
  parameters:
    rate: rate
  states: {}
- name: timing_utils_thresh_trigger_f_0
  id: timing_utils_thresh_trigger_f
  parameters:
    hi: '0.1'
    length: '2'
    low: '0.01'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '80'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_args: args
    gain0: '60'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    samp_rate: rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: usrp_mag
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: trig
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: trig_mag
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: usrp_t
  states: {}
- name: virtual_sink_5_0_0
  id: virtual_sink
  parameters:
    stream_id: trig_t
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: usrp_mag
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: usrp_t
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: trig_t
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: trig
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: trig_mag
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: usrp_t
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: trig_t
  states: {}
- name: virtual_source_9
  id: virtual_source
  parameters:
    stream_id: trig_mag
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5050
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5050
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_1, '0']
- [blocks_add_xx_0, '0', blocks_threshold_ff_0_0_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_2, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_char_to_float_0, '0', blocks_add_xx_0_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_complex_to_mag_0_0_0, '0', blocks_multiply_const_vxx_0_0_1_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_threshold_ff_0_0_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_mag_0_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_float_to_char_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_float_to_char_0_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [blocks_head_0, '0', timing_utils_edge_distance_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_head_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', qtgui_time_sink_x_0, '4']
- [blocks_multiply_const_vxx_0_0_1_0, '0', blocks_add_xx_0, '1']
- [blocks_threshold_ff_0_0_0, '0', virtual_sink_5_0, '0']
- [blocks_threshold_ff_0_0_0_0, '0', virtual_sink_5_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', blocks_char_to_float_0_0, '0']
- [pdu_utils_pdu_to_bursts_X_0, '0', uhd_usrp_sink_0, '0']
- [pdu_utils_tag_message_trigger_X_0, msg, pdu_utils_pdu_to_bursts_X_0, bursts]
- [pdu_utils_tag_message_trigger_X_0, msg, zeromq_pub_msg_sink_0, in]
- [timing_utils_thresh_trigger_f_0, trig, pdu_utils_tag_message_trigger_X_0, ctrl]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '2']
- [virtual_source_1_0, '0', qtgui_time_sink_x_0, '3']
- [virtual_source_1_0_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_2, '0', pdu_utils_tag_message_trigger_X_0, '0']
- [virtual_source_4, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_6, '0', blocks_float_to_char_0_0, '0']
- [virtual_source_7, '0', blocks_float_to_char_0, '0']
- [virtual_source_9, '0', timing_utils_thresh_trigger_f_0, '0']
- [zeromq_sub_msg_source_0, out, pdu_utils_pdu_to_bursts_X_0, bursts]

metadata:
  file_format: 1
