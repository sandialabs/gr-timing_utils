options:
  parameters:
    generate_options: qt_gui
    id: usrp_tag_test
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: tag
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: timing_utils_add_usrp_tags_c_0
  id: timing_utils_add_usrp_tags_c
  parameters:
    freq: '1'
    rate: '1'
    tag_now: tag
    tf: '.1'
    ti: '1'
  states: {}
- name: timing_utils_tag_uhd_offset_X_0
  id: timing_utils_tag_uhd_offset_X
  parameters:
    interval: '10000'
    msg_port: 'False'
    rate: samp_rate
    type: f
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', timing_utils_tag_uhd_offset_X_0, '0']
- [blocks_throttle_0, '0', timing_utils_add_usrp_tags_c_0, '0']
- [timing_utils_add_usrp_tags_c_0, '0', blocks_complex_to_real_0, '0']
- [timing_utils_tag_uhd_offset_X_0, '0', qtgui_time_sink_x_0, '1']
- [timing_utils_tag_uhd_offset_X_0, time, blocks_message_debug_0, print]

metadata:
  file_format: 1
