options:
  parameters:
    generate_options: qt_gui
    id: validate_tt
    output_language: python
  states: {}

blocks:
- name: ati
  id: variable_qtgui_range
  parameters:
    label: Arm tag interval
    orient: Qt.Horizontal
    rangeType: int
    start: '100'
    step: '100'
    stop: '100000'
    value: '10000'
  states: {}
- name: l
  id: variable_qtgui_range
  parameters:
    label: Length Threshold
    orient: Qt.Horizontal
    rangeType: int
    start: '-1'
    step: '1'
    stop: '10000'
    value: '5000'
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: '153600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 19200*8
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '19200'
  states: {}
- name: t
  id: variable_qtgui_range
  parameters:
    label: Threshold
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '2'
    value: '1'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, 1/10.0, 1/40.0, 20)
  states: {}
- name: tl
  id: variable
  parameters:
    value: len(taps)
  states: {}
- name: tti
  id: variable_qtgui_range
  parameters:
    label: Trigger tag interval
    orient: Qt.Horizontal
    rangeType: int
    start: '100'
    step: '100'
    stop: '100000'
    value: '10000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jacob/data/bd2016_data/bd_8xosr.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: int(1.0* rf_rate / (sps * sym_rate))
    taps: firdes.low_pass_2(20, rf_rate, 10000, 10000, 60)
    type: ccc
  states: {}
- name: pdu_utils_tag_message_trigger_asdf_0
  id: pdu_utils_tag_message_trigger_X
  parameters:
    arm_key: pmt.PMT_NIL
    delay_time: '0.0'
    holdoff: '0'
    msg: pmt.cons(pmt.intern("KABOOOOOOM"), pmt.PMT_NIL)
    samp_rate: 1e6
    showport: 'True'
    start_time: '0.0'
    tpdu_mode: 'False'
    trig_key: pmt.intern("TRIGGER")
    type: c
  states: {}
- name: timing_utils_thresh_trigger_f_0
  id: timing_utils_thresh_trigger_f
  parameters:
    hi: t
    length: l
    low: t/10.0
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', fir_filter_xxx_0_0, '0']
- [fir_filter_xxx_0, '0', timing_utils_thresh_trigger_f_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0_0, '0', pdu_utils_tag_message_trigger_asdf_0, '0']
- [pdu_utils_tag_message_trigger_asdf_0, msg, blocks_message_debug_1, print]

metadata:
  file_format: 1
