<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>validate_tt</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ati</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>label</key><value>Arm tag interval</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>100000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>l</value></param>
<param><key>value</key><value>5000</value></param>
<param><key>label</key><value>Length Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_rate</value></param>
<param><key>value</key><value>153600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>19200*8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>19200</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>t</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, 1, 1/10.0, 1/40.0, 20)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tl</value></param>
<param><key>value</key><value>len(taps)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tti</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>label</key><value>Trigger tag interval</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>100000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/jacob/data/bd2016_data/bd_8xosr.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>int(1.0* rf_rate / (sps * sym_rate))</value></param>
<param><key>taps</key><value>firdes.low_pass_2(20, rf_rate, 10000, 10000, 60)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>pdu_utils_tag_message_trigger_X</key>
<param><key>id</key><value>pdu_utils_tag_message_trigger_asdf_0</value></param>
<param><key>arm_key</key><value>pmt.PMT_NIL</value></param>
<param><key>showport</key><value>True</value></param>
<param><key>delay_time</key><value>0.0</value></param>
<param><key>holdoff</key><value>0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.intern("KABOOOOOOM"), pmt.PMT_NIL)</value></param>
<param><key>tpdu_mode</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>start_time</key><value>0.0</value></param>
<param><key>trig_key</key><value>pmt.intern("TRIGGER")</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>timing_utils_thresh_trigger_f</key>
<param><key>id</key><value>timing_utils_thresh_trigger_f_0</value></param>
<param><key>length</key><value>l</value></param>
<param><key>hi</key><value>t</value></param>
<param><key>low</key><value>t/10.0</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>timing_utils_thresh_trigger_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>pdu_utils_tag_message_trigger_asdf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdu_utils_tag_message_trigger_asdf_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>msg</source_key><sink_key>print</sink_key></connection>
</flow_graph>
