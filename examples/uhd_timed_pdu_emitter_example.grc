<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_timed_pdu_emitter_example</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ts</value></param>
<param><key>value</key><value>2</value></param>
<param><key>label</key><value>Trigger (s)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.from_uint64(ts+2), pmt.from_double(0.123))</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.from_uint64(ts*samp_rate)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>This block accepts either a uint64 PMT representing
the specific sample to trigger on, or a UHD style PMT
pair of {uint64, double} representing the UHD time.</value></param>
<param><key>note</key><value>TRIGGER FORMAT</value></param>
</block>
<block>
<key>timing_utils_add_usrp_tags_c</key>
<param><key>id</key><value>timing_utils_add_usrp_tags_c_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>1000000</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>tag_now</key><value>0</value></param>
<param><key>tf</key><value>0.493</value></param>
<param><key>ti</key><value>4</value></param>
</block>
<block>
<key>timing_utils_uhd_timed_pdu_emitter</key>
<param><key>id</key><value>timing_utils_uhd_timed_pdu_emitter_0</value></param>
<param><key>comment</key><value>BLOCK UNDER TEST</value></param>
<param><key>late_pdu_mode</key><value>True</value></param>
<param><key>rate</key><value>samp_rate</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>100e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>timing_utils_uhd_timed_pdu_emitter_0</sink_block_id><source_key>strobe</source_key><sink_key>set</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>timing_utils_uhd_timed_pdu_emitter_0</sink_block_id><source_key>strobe</source_key><sink_key>set</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>timing_utils_add_usrp_tags_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>timing_utils_add_usrp_tags_c_0</source_block_id><sink_block_id>timing_utils_uhd_timed_pdu_emitter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>timing_utils_uhd_timed_pdu_emitter_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>trig</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>timing_utils_uhd_timed_pdu_emitter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
