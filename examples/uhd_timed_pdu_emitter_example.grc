options:
  parameters:
    generate_options: qt_gui
    id: uhd_timed_pdu_emitter_example
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: ts
  id: variable_qtgui_range
  parameters:
    label: Trigger (s)
    orient: Qt.Horizontal
    rangeType: int
    start: '2'
    step: '1'
    stop: '100'
    value: '2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.from_uint64(ts+2), pmt.from_double(0.123))
    period: '1000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.from_uint64(ts*samp_rate)
    period: '1000'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: |-
      This block accepts either a uint64 PMT representing
      the specific sample to trigger on, or a UHD style PMT
      pair of {uint64, double} representing the UHD time.
    note: TRIGGER FORMAT
  states: {}
- name: timing_utils_add_usrp_tags_c_0
  id: timing_utils_add_usrp_tags_c
  parameters:
    freq: '1000000'
    rate: samp_rate
    tag_now: '0'
    tf: '0.493'
    ti: '4'
  states: {state: disabled}
- name: timing_utils_uhd_timed_pdu_emitter_0
  id: timing_utils_uhd_timed_pdu_emitter
  parameters:
    comment: BLOCK UNDER TEST
    late_pdu_mode: 'True'
    rate: samp_rate
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: 100e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_message_strobe_0, strobe, timing_utils_uhd_timed_pdu_emitter_0, set]
- [blocks_message_strobe_0_0, strobe, timing_utils_uhd_timed_pdu_emitter_0, set]
- [blocks_throttle_0, '0', timing_utils_add_usrp_tags_c_0, '0']
- [timing_utils_add_usrp_tags_c_0, '0', timing_utils_uhd_timed_pdu_emitter_0, '0']
- [timing_utils_uhd_timed_pdu_emitter_0, trig, blocks_message_debug_0, print]
- [uhd_usrp_source_0, '0', timing_utils_uhd_timed_pdu_emitter_0, '0']

metadata:
  file_format: 1
